# Keil uVision project Watch.uvprojx, settings and files
target Watch (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F450ZE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Watch
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: .\USER\System;.\Drivers\CMSIS;.\Library\Include;..\OV-Watch;.\BSP\Inc;.\Core\Inc;.\USER\Tasks\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./: main.c
  group Application/User/Tasks
    ./USER/Tasks/Src/: user_TasksInit.c
  group BSP
    ./BSP/Src/: gpio.c usart.c key.c timer.c
  group Core
    ./Core/Src/: freertos.c
  group Library
    ./Library/Source/: gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_rcu.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_misc.c gd32f4xx_timer.c
  group CMSIS
    ./Drivers/CMSIS/: gd32f4xx_it.c
  group System
    ./USER/System/: systick.c
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.3.1, Device:Startup 3.0.2
